# Keil uVision project DeskClock.uvprojx, settings and files
target DeskClock (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L471RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: DeskClock +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L471xx,EPD_VENDOR_DEMO_MODE=0,EPD_CLOCK_USE_GRAY4=0,LFS_NO_MALLOC,LFS_NO_DEBUG,LFS_NO_WARN,LFS_NO_ERROR,LFS_NAME_MAX=31
  c include: ../middleware;../app;../device;../platform;../gui;../fonts;../resources;../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l471xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c lptim.c rtc.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_lptim.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group app
    ../app/: buttons.c power.c accel.c accel.h vofa.c debug.c debug.h vofa.h display.c display.h epd_bringup.c epd_bringup.h epd_clock_view.c epd_clock_view.h epd_weather_view.c epd_weather_view.h epd_vendor_demo.c epd_vendor_demo.h storage.c storage.h storage_files.h file_transfer.c file_transfer.h clock_model.c clock_model.h clock_faults.c clock_faults.h clock_service.c clock_service.h clock_schedule.c clock_schedule.h clock_config.c clock_config.h debug_console.c debug_console.h weather.c weather.h forecast.c forecast.h forecast_protocol.c forecast_protocol.h storage_forecast.h weather_feed.c weather_feed.h time_protocol.c time_protocol.h epd_weather_pages.c epd_weather_pages.h
  group middleware
    ../middleware/: button_filter.c file_store.c file_store.h
    ../middleware/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
  group device
    ../device/: imu_adxl345.c imu_adxl345.h epd_gdey029t94.c epd_gdey029t94.h flash_w25q128.c flash_w25q128.h
  group platform
    ../platform/: stm32_buttons.c stm32_gpio_exti.c stm32_low_power.c low_power_time.c stm32_adxl345.c stm32_adxl345.h stm32_debug_uart.c stm32_debug_uart.h stm32_gdey029t94.c stm32_gdey029t94.h stm32_w25q128.c stm32_w25q128.h stm32_clock.c stm32_clock.h
  group gui
    ../gui/: GUI_Paint.c GUI_Paint.h
  group fonts
    ../fonts/: font12.c font12CN.c font16.c font20.c font24.c font24CN.c font8.c fonts.h fonts_cn.h
  group resources
    ../resources/: epd_vendor_assets.c epd_vendor_assets.h clock_gray_assets.c clock_gray_assets.h weather_glyphs.c weather_glyphs.h weather_pages_assets.c weather_pages_assets.h
software components: CMSIS:CORE 4.3.0
