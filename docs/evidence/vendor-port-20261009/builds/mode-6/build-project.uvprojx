# Keil uVision project build-project.uvprojx, settings and files
target elinkTest (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L471RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: elinkTest +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L471xx,EPD_VENDOR_DEMO_MODE=6
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l471xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c rtc.c spi.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Application/User/App
    ../app/: epd_vendor_demo.c epd_bringup.c epd_clock_view.c
  group Application/User/GUI
    ../gui/: GUI_Paint.c
  group Application/User/Fonts
    ../fonts/: font12CN.c font24CN.c font8.c font12.c font16.c font20.c font24.c
  group Application/User/Device
    ../device/: epd_gdey029t94.c
  group Application/User/Resources
    ../resources/: epd_vendor_assets.c
  group Application/User/Platform
    ../platform/: stm32_gdey029t94.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
